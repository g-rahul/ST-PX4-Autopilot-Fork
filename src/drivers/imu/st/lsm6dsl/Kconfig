## src/drivers/imu/st/lsm6dsl/Kconfig
```kconfig
menuconfig DRIVERS_IMU_ST_LSM6DSL
	bool "lsm6dsl"
	default n
	---help---
		Enable support for lsm6dsl
```
